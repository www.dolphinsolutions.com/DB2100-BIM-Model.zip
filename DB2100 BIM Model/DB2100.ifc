Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-03-24T09:09:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 24 09:09:53 2025 * Host: PPDE609AE2 * Database: C:\Users\G71DC~1.MAG\AppData\Local\Temp\90e2c3ba-c732-48b4-bc46-c7a4662028a0\721560c5-1eb1-443f-82a1-be3767cf8628\ifc * Database version: 5507 * Database creation date: Mon Mar 24 09:09:49 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 24 09:09:49 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 24 09:09:49 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: DB2100:DB2100, DB2100:DB2100:309837
In: Level 0
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_84:Sink Taps; CAWS: N11/30 SinksTapsTrapsAndwWastes_N11/350 SinksTapsTrapsAndWastes_N12/380 SinksTapsTrapsAndWastes_N12/380 SinksTapsTrapsAndWastes; CodePerformance: WRAS; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: KitchenSinkTap; DurationUnit: year; ExpectedLife: n/a; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Form: CounterMounted; IfcExportAs: IfcValveType; IfcExportType: FAUCET; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; ModelNumber: DB2100; ModelReference: DolphinSolutionsLimited_KitchenSinkTap; Name: KitchenSinkTap_DB2100_DolphinSolutionsLimited; NBSDescription: SinkTaps; NBSReference: 45-35-70/345; NBSTypeID: n/a; NominalHeight: 404mm; NominalLength: 227 mm; NominalWidth: 50 mm; ObjectClassification: 23.45.55.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Operation: Manual_Lever; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 404 x 227 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB2100; Uniclass2015Code: Pr_40_20_87_84; Uniclass2015Title: Sink Taps; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Other - Category: Plumbing Fixtures; Family Name: DB2100
Type - Pset_DistributionFlowElementCommon - Reference: DB2100:DB2100
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_KitchenSinkTap; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: KitchenSinkTap_DB2100_DolphinSolutionsLimited; Category: Pr_40_20_87_84:Sink Taps
Type - Pset_QuantityTakeOff - Reference: DB2100:DB2100
Type - Pset_ValveTypeFaucet - Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated
Pset_DistributionFlowElementCommon - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0608223 m2; Volume: 0.000375381 m3
Identity Data - Mark: 1
Other - Family: DB2100: DB2100; Family and Type: DB2100: DB2100; Type: DB2100: DB2100; Type Id: DB2100: DB2100
Phasing - Phase Created: New Construction
